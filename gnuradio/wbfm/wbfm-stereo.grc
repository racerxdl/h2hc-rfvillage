options:
  parameters:
    author: Lucas Teske
    generate_options: qt_gui
    id: wbfm_tx
    output_language: python
    title: Wideband FM Radio Transmitter
  states: {}

blocks:
- name: audio_sr
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: fm_max_dev
  id: variable
  parameters:
    value: 80e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Audio Gain
    start: '0'
    step: '1'
    stop: '400'
    value: '50'
  states: {}
- name: multiplier
  id: variable
  parameters:
    value: '10'
  states: {}
- name: outbuffer
  id: variable
  parameters:
    value: '10'
  states: {}
- name: pre_fm_gain
  id: variable_qtgui_range
  parameters:
    label: Pre FM Gain
    start: '0'
    step: '1'
    stop: '400'
    value: '50'
  states: {}
- name: rdsgain
  id: variable_qtgui_range
  parameters:
    label: RDS Gain
    start: '0'
    step: '1'
    stop: '4000'
    value: '250'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: audio_sr*multiplier
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: audio_sr*multiplier
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.08'
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: multiplier*audio_sr
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '0.03'
    freq: '38000'
    offset: '0'
    phase: '0'
    samp_rate: multiplier*audio_sr
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '57000'
    offset: '0'
    phase: '0'
    samp_rate: 380e3
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    samp_rate: '32000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '10'
    high_cutoff_freq: 48e3
    low_cutoff_freq: 25e3
    samp_rate: multiplier*audio_sr
    type: fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rdsgain/1000.0
    maxoutbuf: outbuffer
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '160'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: gr_char_to_float_0
  id: blocks_char_to_float
  parameters:
    maxoutbuf: outbuffer
    scale: '1'
  states: {}
- name: gr_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    maxoutbuf: outbuffer
    modulus: '2'
  states: {}
- name: gr_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    maxoutbuf: outbuffer
    sensitivity: 2*math.pi*fm_max_dev/(multiplier*audio_sr)
  states: {}
- name: gr_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,2]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
    maxoutbuf: outbuffer
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2.5e3
    gain: '1'
    interp: '1'
    maxoutbuf: outbuffer
    samp_rate: 380e3
    type: interp_fir_filter_fff
    width: .5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '160000'
    decim: '1'
    gain: '1'
    samp_rate: multiplier*audio_sr*2
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 60e3
    decim: '1'
    gain: pre_fm_gain/100.0
    samp_rate: audio_sr*multiplier
    type: fir_filter_fff
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: float(gain)/150
    interp: '1'
    samp_rate: multiplier*audio_sr
    type: interp_fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: float(gain)/100
    interp: '1'
    samp_rate: multiplier*audio_sr
    type: interp_fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: FM Mixer
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Baseband Modulator
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: RDS Modulator
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: Stereo Audio Mix
  states: {}
- name: note_0_0_0_0_0
  id: note
  parameters:
    note: Mono Audio Mix
  states: {}
- name: note_0_0_0_0_0_0
  id: note
  parameters:
    note: FM Stereo Pilot
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: multiplier*audio_sr*2
    fc: '0'
    fftsize: '4096'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: int(multiplier*audio_sr)
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    showports: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '64'
    interp: '500'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '380'
    interp: int((multiplier*audio_sr)/1000)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: multiplier
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: multiplier
    taps: ''
    type: fff
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 89.8e6
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: WDR 3
    pty: '14'
    pty_locale: '0'
    radiotext: GNU Radio <3
    ta: 'False'
    tp: 'True'
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: center_freq
    dev_args: serial=1D4259E26B9B38
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audio_left
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: audio_right
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: fm_pilot
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: audio_right_mod
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: rds_mod
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: fm_composite
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audio_right
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: audio_left
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: fm_pilot
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: audio_right_mod
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: rds_mod
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: fm_composite
  states: {}

connections:
- [analog_fm_preemph_0, '0', low_pass_filter_2_0, '0']
- [analog_fm_preemph_0_0, '0', low_pass_filter_2_0_0, '0']
- [analog_sig_source_x_0, '0', virtual_sink_1, '0']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1_0_0, '0', blocks_multiply_xx_0_0, '1']
- [audio_source_0, '0', blocks_add_xx_0_0_0, '0']
- [audio_source_0, '0', blocks_sub_xx_0, '0']
- [audio_source_0, '1', blocks_add_xx_0_0_0, '1']
- [audio_source_0, '1', blocks_sub_xx_0, '1']
- [band_pass_filter_0, '0', virtual_sink_2, '0']
- [blocks_add_xx_0, '0', low_pass_filter_2, '0']
- [blocks_add_xx_0_0_0, '0', rational_resampler_xxx_2, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_3, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_repeat_0, '0', low_pass_filter_0, '0']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_2_0, '0']
- [gr_char_to_float_0, '0', blocks_repeat_0, '0']
- [gr_diff_encoder_bb_0, '0', gr_map_bb_1, '0']
- [gr_frequency_modulator_fc_0, '0', virtual_sink_4, '0']
- [gr_map_bb_0, '0', gr_char_to_float_0, '0']
- [gr_map_bb_1, '0', gr_unpack_k_bits_bb_0, '0']
- [gr_unpack_k_bits_bb_0, '0', gr_map_bb_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_2, '0', gr_frequency_modulator_fc_0, '0']
- [low_pass_filter_2, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_2_0, '0', virtual_sink_0, '0']
- [low_pass_filter_2_0_0, '0', virtual_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', soapy_limesdr_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_2, '0', analog_fm_preemph_0, '0']
- [rational_resampler_xxx_2_0, '0', analog_fm_preemph_0_0, '0']
- [rds_encoder_0, '0', gr_diff_encoder_bb_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_1, '0', blocks_add_xx_0, '0']
- [virtual_source_2, '0', blocks_add_xx_0, '1']
- [virtual_source_3, '0', blocks_add_xx_0, '2']
- [virtual_source_4, '0', blocks_add_xx_0, '3']
- [virtual_source_5, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
