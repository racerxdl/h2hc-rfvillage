options:
  parameters:
    author: H2HC
    generate_options: qt_gui
    id: modem_fsk_rx
    output_language: python
    title: FSK Modem RX
  states: {}

blocks:
- name: fsk_deviation_hz
  id: variable
  parameters:
    comment: |-
      Desvio máximo do FSK
      Valor Max - Valor Min
      2200 -1200 = 1000 Hz
    value: 2200-1200
  states: {}
- name: passa_baixa
  id: variable_low_pass_filter_taps
  parameters:
    comment: |-
      Filtro passa baixa para o bloco
      de frequency shift. O ponto
      de filtro é configurado para
      frequencia "central", com a
      transição para o desvio maximo.
    cutoff_freq: '1700'
    gain: '1'
    samp_rate: samp_rate
    width: fsk_deviation_hz/2
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Taxa de Amostragem
      Em amostras por segundo
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: |-
      Amostras por símbolo
      samp_rate / symbol_rate
    value: int(samp_rate/symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: |-
      Taxa de Símbolos
      Em Símbolos por segundo
    value: '1200'
  states: {}
- name: syncdata
  id: variable
  parameters:
    comment: |-
      Palavra de Sincronia
      (Hexadecimal)
    value: '"DEADBEEF1337"'
  states: {}
- name: syncdata_bits
  id: variable
  parameters:
    comment: |-
      Palavra de Sincronia
      (Convertido pra bits)
    value: '"".join(["{:08b}".format(b) for b in binascii.unhexlify(syncdata)])'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      Aqui convertemos o sinal
      de frequência para intensidade.
      Basicamente -24kHz irá virar -1
      e 24kHz irá virar 1. Por causa 
      do deslocamento feito no bloco
      anterior, agora teremos nossos
      bits representados pelo sinal do 
      numero de saída.
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      E podemos agora
      salvar o resultado num arquivo
    file: demod.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      E podemos usar isso para imprimir
      no console toda vez que recebermos
      um PDU
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Nossos bits são invertidos, lembra?
      A saída do demodulador é centrada
      em 1700Hz, que é exatamente o 
      meio dos bits. Logo temos um valor
      de bit pra -0.5 e outro pra 0.5.
      Como é invertido, aqui basta 
      multiplicar por -1
    const: '-1'
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: |-
      Agora re-empacotamos cada bit
      como um byte
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      Como agora temos uma "tagged stream"
      precisamos usar o Repack ao invés do pack
      para preservar / recalcular o valor da tag
      "packet_len"
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    comment: |-
      Esse bloco vai procurar pela
      primeira tag e alinhar a saída
      a ela.
    lengthtagname: synchead
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: |-
      Configuramos
      o fluxo para samp_rate
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/lucas/Works/h2hc2022/h2hc-2022-rfvillage/gnuradio/datamodulated.wav
    repeat: 'True'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: |-
      Aqui vamos fazer o "slice" dos
      valores. 
      Se for < 0 a saída é 0
      Se for > 0 a saída é 1
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: |-
      Precisamos achar a sincronia
      para isso iremos usar o mágico
      M&M Clock Recovery onde
      Omega é o numero de simbolos
      por amostra (sps)
      O resto dos parametros é o padrão
      do GNU Radio
    gain_mu: '0.175'
    gain_omega: '0.1'
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: syncdata_bits
    comment: |-
      Agora vamos procurar pela
      nossa palavra de sincronia.
      Como podemos estar recebendo
      o dado em "qualquer posição" de bits
      precisamos garantir que os bits estão
      alinhados a bytes da origem. Esse bloco
      irá marcar toda vez que encontrar o 
      "Access Code" na stream de bits com a tag
      "synchead". O campo threshold especifica
      a tolerancia de bits errados na sequência
    tagname: synchead
    threshold: '4'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: syncdata_bits
    comment: |-
      Com TagStream podemos sincronizar
      com um tamanho de pacote definido
      no header. Nosso pacote de exemplo
      tem dois grupos de 2 bytes representando
      o tamanho do payload, logo após
      o access code.
    tagname: packet_len
    threshold: '4'
    type: byte
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '1700'
    comment: |-
      Movemos o sinal 1.7kHz para o "lado"
      dessa maneira, nossa faixa central
      (que era 1.7kHz) agora está em 0, e um
      bit é representado por uma frequência 
      negativa e outro pela positiva.

      Para a representação ficar correta,
      convertemos para um número complexo.
    decim: '1'
    samp_rate: samp_rate
    taps: passa_baixa
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    comment: Python ¯\_(ツ)_/¯
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import binascii
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      As palavras de sincronia
      aqui definidas, estão no 
      arquivo binário. Elas são
      utilizadas para facilitar
      a decodificação e sincronia.

      Adicionalmente, um "preâmbulo"
      é adicionado para ajudar o clock
      sync a achar o clock correto. Esse
      preambulo é bits 0 e 1 alternados
      dentro de um byte. Em hexadecimal
      a sequencia é 0x55 0xAA
    note: Notas das variáveis
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: |-
      Agora podemos transformar
      em um "PDU" que é basicamente
      uma mensagem.
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    comment: |-
      Visualização pra observar 
      a transição entre 0 -> 1 e 1->0
    samp_per_symbol: sps
    size: '16384'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Uma visualização do espectro após o filtro
    fc: '0'
    fftsize: '1024'
    norm_window: 'True'
    type: complex
    ymax: '0'
    ymin: '-50'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: |-
      Agora criamos a stream
      do sinal demodulado :D
    stream_id: demodulado
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bits_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demodulado
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: bits_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: bits_out
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [digital_binary_slicer_fb_0, '0', virtual_sink_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', blocks_tagged_stream_align_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [virtual_source_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [virtual_source_0, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_1, '0', digital_correlate_access_code_tag_xx_1, '0']
- [virtual_source_1_0, '0', digital_correlate_access_code_xx_ts_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
