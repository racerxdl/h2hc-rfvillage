options:
  parameters:
    author: H2HC
    generate_options: qt_gui
    id: modem_fsk_tx
    output_language: python
    title: FSK Modem TX
  states: {}

blocks:
- name: fsk_deviation
  id: variable
  parameters:
    comment: |-
      Desvio máximo do FSK
      Valor Max - Valor Min
      2200 -1200 = 1000 Hz
    value: 2200-1200
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Taxa de Amostragem
      Em amostras por segundo
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: |-
      Amostras por símbolo
      samp_rate / symbol_rate
    value: int(samp_rate/symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: |-
      Taxa de Símbolos
      Em Símbolos por segundo
    value: '1200'
  states: {}
- name: vco_center
  id: variable
  parameters:
    comment: |-
      Frequência central (valor mínimo)
      Neste caso, valor do bit 1
    value: '1700'
  states: {}
- name: vco_max
  id: variable
  parameters:
    comment: |-
      Frequência máxima do VCO
      Para uma entrada de valor 1f
      no VCO, esta será a frequência
      de saída.
    value: '2500'
  states: {}
- name: vco_offset
  id: variable
  parameters:
    comment: |-
      Offset do VCO
      vco_center/vco_max
      1200/2500 = 0.48
    value: (vco_center-(fsk_deviation/2))/vco_max
  states: {}
- name: vco_sensitivity
  id: variable
  parameters:
    comment: |-
      Sensibilidade do VCO em radianos.
      Só conversão de Hz pra radianos / s
      2 * pi * vco_max
    value: (2 * math.pi * vco_max)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      Podemos mandar o sinal
      direto pra placa de som!
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: Adicionamos o offset
    const: vco_offset+0.4
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Arquivo de origem
        (lendo em bytes)
    file: basebin.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Multiplicamos por -0.4
    const: '-0.4'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      Repetimos "sps" vezes cada bit
      definindo que cada bit é um símbolo.
    interp: sps
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters:
    comment: |-
      Convertemos "byte" (aqui bit)
      para float (0 e 1 em float)
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      Pegando cada byte e "desmontando"
      ele em bits.
      Por exemplo: 11110000 irá virar um
      array de 8 bytes: [1,1,1,1,0,0,0,0]
    k: '8'
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.5'
    samp_rate: samp_rate
    sensitivity: vco_sensitivity
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: Ou salvar um arquivo de áudio
    file: datamodulated.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    comment: Python ¯\_(ツ)_/¯
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Seguiremos algo parecido com modem Bell 202
      Toda vez que transmitirmos bit 1, usaremos tom de 1200Hz
      Toda vez que transmitirmos bit 0, usaremos tom de 2200Hz

      Usualmente o bit 0 é chamado de ESPAÇO (SPACE) e bit 1 
      é chamado de MARCADOR ou MARCA (MARK)

      Para gerar os sinais iremos usar um VCO (Voltage Controlled Oscillator)
      Um VCO tem um rate de volts por hertz para sua saída,
      então determinaremos um range para gerar os sinais 1200/2200 Hz
      de acordo com os bits 0f e 1f que recebemos de bits_dos_dados

      Se definirmos o VCO_MAX para 2500Hz, isso significa que caso um
      sinal de valor 1 entre no VCO, a saída será 2500Hz. Então podemos
      fazer:

      Tom bit 0: 2200/2500 = 0.88f
      Tom bit 1: 1200/2500 = 0.48f

      Como ambos valores são diferentes de 0, podemos especificar 
      um offset para o valor "padrão", porém neste caso o 0 é a frequência
      mais alta, então iremos inverter os bits para o "padrão" virar o tom de 
      1200. Usando o offset 0.48f teremos:

      2200 => 0.4f + 0.48f
      1200 => 0.0f + 0.48f

      E como podemos inverter o bit? Assumindo que só valores 0 e 1 
      chegam:

      Xinv = 1f - X 

      Com isso temos que dado X sendo o valor do bit em float na 
      entrada do VCO precisa ser:

      VCO = 1f * 0.4 + 0.48f - X * 0.4
      VCO = 0.88f -  X * 0.4
      VCO = -0.4 * X + 0.88f
    note: Explicação do Rádio
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Visualização do sinal gerado :D
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    norm_window: 'True'
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: |-
      Criamos um fluxo de saída
      para os "dados" a serem
      transmitidos.
      Para bit 0 teremos valor 0f
      Para bit 1 teremos valor 1f
    stream_id: bits_dos_dados
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    comment: |-
      Aqui temos nossa saída com
      os bits modulados em FSK!
    stream_id: saida_fsk
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: |-
      Aqui coletamos os bits
      gerados acima.
    stream_id: bits_dos_dados
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: Nosso sinal modulado
    stream_id: saida_fsk
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_vco_f_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_1, '0', audio_sink_0, '0']
- [virtual_source_1, '0', blocks_wavfile_sink_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
